include common-root-passwd.inc