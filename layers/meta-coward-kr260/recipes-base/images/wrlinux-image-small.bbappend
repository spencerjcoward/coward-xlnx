include common-root-passwd.inc

EXTRA_USERS_PARAMS += "useradd -p '\$1\$tNgDV4Qe\$7rB0LfWOHH77g6IBfKiXs0' -G sudo -d /home/wrlinux -m wrlinux;"