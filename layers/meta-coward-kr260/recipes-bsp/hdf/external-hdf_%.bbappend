FILESEXTRAPATHS:append := ":${THISDIR}/files"

SRC_URI += "file://kr260_plane_jane.xsa"